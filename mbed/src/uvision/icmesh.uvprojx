# Keil uVision project icmesh.uvprojx, settings and files
target icmesh (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC11U24FBD48/401 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  output: icmesh
  AfterMake: fromelf --bin -o BUILD\icmesh.bin BUILD\icmesh.axf
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_LPC11UXX -DDEVICE_SEMIHOST=1 -DTARGET_LPC11U24_401 -D__ASSERT_MSG --no_rtti -Otime -DDEVICE_PORTINOUT=1 -c -O3 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DTARGET_RELEASE --split_sections -DTARGET_LIKE_CORTEX_M0 -DARM_MATH_CM0 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 --cpu=Cortex-M0 -D__CORTEX_M0 -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 -DTARGET_LPC11U24 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu -DMBED_BUILD_TIMESTAMP=1488497801.52 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_LOCALFILESYSTEM=1 -DDEVICE_SERIAL=1 -DTARGET_M0 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DTARGET_NXP -D__MBED_CMSIS_RTOS_CM
  c include: .; LSM303DLHC; nRF24L01P; mbed/.; mbed/TARGET_LPC11U24; mbed/TARGET_LPC11U24/TARGET_NXP; mbed/TARGET_LPC11U24/TARGET_NXP/TARGET_LPC11UXX; mbed/TARGET_LPC11U24/TARGET_NXP/TARGET_LPC11UXX/TARGET_LPC11U24_401; mbed/TARGET_LPC11U24/TARGET_NXP/TARGET_LPC11UXX/device; mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD; mbed/drivers; mbed/hal; mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M0,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-DARM_MATH_CM0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD/LPC11U24.sct
  group 
    ./: mbed_config.h main.cpp
  group TARGET_LPC11UXX
    mbed/TARGET_LPC11U24/TARGET_NXP/TARGET_LPC11UXX/: PeripheralPins.h PortNames.h gpio_object.h objects.h
  group hal
    mbed/hal/: Driver_Common.h Driver_Storage.h analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h emac_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
  group platform
    mbed/platform/: CThunk.h CallChain.h Callback.h CircularBuffer.h FunctionPointer.h PlatformMutex.h SingletonPtr.h Transaction.h critical.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_preprocessor.h mbed_stats.h platform.h rtc_time.h semihost_api.h toolchain.h wait_api.h
  group TARGET_LPC11U24_401
    mbed/TARGET_LPC11U24/TARGET_NXP/TARGET_LPC11UXX/TARGET_LPC11U24_401/: PeripheralNames.h PinNames.h device.h
  group drivers
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
  group TARGET_NXP
    mbed/TARGET_LPC11U24/TARGET_NXP/: mbed_rtx.h
  group LSM303DLHC
    LSM303DLHC/: LSM303DLHC.h LSM303DLHC.cpp
  group nRF24L01P
    nRF24L01P/: nRF24L01P.h nRF24L01P.cpp
  group device
    mbed/TARGET_LPC11U24/TARGET_NXP/TARGET_LPC11UXX/device/: LPC11Uxx.h cmsis.h cmsis_nvic.h power_api.h system_LPC11Uxx.h
  group TARGET_LPC11U24
    mbed/TARGET_LPC11U24/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_caFunc.h core_caInstr.h core_ca_mmu.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD/: PeripheralPins.o analogin_api.o cmsis_nvic.o gpio_api.o gpio_irq_api.o i2c_api.o mbed_board.o pinmap.o port_api.o pwmout_api.o retarget.o serial_api.o sleep.o spi_api.o startup_LPC11xx.o sys.o system_LPC11Uxx.o us_ticker.o mbed.ar
  group mbed
    mbed/: mbed.h
